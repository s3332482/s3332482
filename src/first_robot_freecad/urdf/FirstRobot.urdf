Commit message: changes

File: src/first_robot_freecad/urdf/FirstRobot.urdf (robot description, URDF)
Before this commit: robot Robot, 4 links, 3 joints
Links:
- link caster_wheel: geometry collision sphere radius=0.02; visual sphere radius=0.02
